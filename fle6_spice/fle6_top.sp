**generated by create_stimulus.py
.options linsol type=aztecoo
.include "fle6.sp"
Xfle6 VSS clk in.0 in.1 in.2 in.3 in.4 in.5 cin out.0 out.1 cout prog_done prog_data.0 prog_data.1 prog_data.2 prog_data.3 prog_data.4 prog_data.5 prog_data.6 prog_data.7 prog_data.8 prog_data.9 prog_data.10 prog_data.11 prog_data.12 prog_data.13 prog_data.14 prog_data.15 prog_data.16 prog_data.17 prog_data.18 prog_data.19 prog_data.20 prog_data.21 prog_data.22 prog_data.23 prog_data.24 prog_data.25 prog_data.26 prog_data.27 prog_data.28 prog_data.29 prog_data.30 prog_data.31 prog_data.32 prog_data.33 prog_data.34 prog_data.35 prog_data.36 prog_data.37 prog_data.38 prog_data.39 prog_data.40 prog_data.41 prog_data.42 prog_data.43 prog_data.44 prog_data.45 prog_data.46 prog_data.47 prog_data.48 prog_data.49 prog_data.50 prog_data.51 prog_data.52 prog_data.53 prog_data.54 prog_data.55 prog_data.56 prog_data.57 prog_data.58 prog_data.59 prog_data.60 prog_data.61 prog_data.62 prog_data.63 prog_data.64 prog_data.65 prog_data.66 prog_data.67 prog_data.68 prog_data.69 fle6
.tran 1p 41000p uic
Vclk clk 0 PWL FILE "17.pwl"
Vin.0 in.0 0 PWL FILE "469061.pwl"
Vin.1 in.1 0 PWL FILE "469062.pwl"
Vin.2 in.2 0 PWL FILE "469063.pwl"
Vin.3 in.3 0 PWL FILE "469064.pwl"
Vin.4 in.4 0 PWL FILE "469065.pwl"
Vin.5 in.5 0 PWL FILE "469066.pwl"
Vcin cin 0 PWL FILE "4762.pwl"
Vprog_done prog_done 0 PWL FILE "469060.pwl"
Vprog_data.0 prog_data.0 0 PWL FILE "469067.pwl"
Vprog_data.1 prog_data.1 0 PWL FILE "469068.pwl"
Vprog_data.2 prog_data.2 0 PWL FILE "469069.pwl"
Vprog_data.3 prog_data.3 0 PWL FILE "469070.pwl"
Vprog_data.4 prog_data.4 0 PWL FILE "469071.pwl"
Vprog_data.5 prog_data.5 0 PWL FILE "469072.pwl"
Vprog_data.6 prog_data.6 0 PWL FILE "469073.pwl"
Vprog_data.7 prog_data.7 0 PWL FILE "469074.pwl"
Vprog_data.8 prog_data.8 0 PWL FILE "469075.pwl"
Vprog_data.9 prog_data.9 0 PWL FILE "469076.pwl"
Vprog_data.10 prog_data.10 0 PWL FILE "469077.pwl"
Vprog_data.11 prog_data.11 0 PWL FILE "469078.pwl"
Vprog_data.12 prog_data.12 0 PWL FILE "469079.pwl"
Vprog_data.13 prog_data.13 0 PWL FILE "469080.pwl"
Vprog_data.14 prog_data.14 0 PWL FILE "469081.pwl"
Vprog_data.15 prog_data.15 0 PWL FILE "469082.pwl"
Vprog_data.16 prog_data.16 0 PWL FILE "469083.pwl"
Vprog_data.17 prog_data.17 0 PWL FILE "469084.pwl"
Vprog_data.18 prog_data.18 0 PWL FILE "469085.pwl"
Vprog_data.19 prog_data.19 0 PWL FILE "469086.pwl"
Vprog_data.20 prog_data.20 0 PWL FILE "469087.pwl"
Vprog_data.21 prog_data.21 0 PWL FILE "469088.pwl"
Vprog_data.22 prog_data.22 0 PWL FILE "469089.pwl"
Vprog_data.23 prog_data.23 0 PWL FILE "469090.pwl"
Vprog_data.24 prog_data.24 0 PWL FILE "469091.pwl"
Vprog_data.25 prog_data.25 0 PWL FILE "469092.pwl"
Vprog_data.26 prog_data.26 0 PWL FILE "469093.pwl"
Vprog_data.27 prog_data.27 0 PWL FILE "469094.pwl"
Vprog_data.28 prog_data.28 0 PWL FILE "469095.pwl"
Vprog_data.29 prog_data.29 0 PWL FILE "469096.pwl"
Vprog_data.30 prog_data.30 0 PWL FILE "469097.pwl"
Vprog_data.31 prog_data.31 0 PWL FILE "469098.pwl"
Vprog_data.32 prog_data.32 0 PWL FILE "469099.pwl"
Vprog_data.33 prog_data.33 0 PWL FILE "469100.pwl"
Vprog_data.34 prog_data.34 0 PWL FILE "469101.pwl"
Vprog_data.35 prog_data.35 0 PWL FILE "469102.pwl"
Vprog_data.36 prog_data.36 0 PWL FILE "469103.pwl"
Vprog_data.37 prog_data.37 0 PWL FILE "469104.pwl"
Vprog_data.38 prog_data.38 0 PWL FILE "469105.pwl"
Vprog_data.39 prog_data.39 0 PWL FILE "469106.pwl"
Vprog_data.40 prog_data.40 0 PWL FILE "469107.pwl"
Vprog_data.41 prog_data.41 0 PWL FILE "469108.pwl"
Vprog_data.42 prog_data.42 0 PWL FILE "469109.pwl"
Vprog_data.43 prog_data.43 0 PWL FILE "469110.pwl"
Vprog_data.44 prog_data.44 0 PWL FILE "469111.pwl"
Vprog_data.45 prog_data.45 0 PWL FILE "469112.pwl"
Vprog_data.46 prog_data.46 0 PWL FILE "469113.pwl"
Vprog_data.47 prog_data.47 0 PWL FILE "469114.pwl"
Vprog_data.48 prog_data.48 0 PWL FILE "469115.pwl"
Vprog_data.49 prog_data.49 0 PWL FILE "469116.pwl"
Vprog_data.50 prog_data.50 0 PWL FILE "469117.pwl"
Vprog_data.51 prog_data.51 0 PWL FILE "469118.pwl"
Vprog_data.52 prog_data.52 0 PWL FILE "469119.pwl"
Vprog_data.53 prog_data.53 0 PWL FILE "469120.pwl"
Vprog_data.54 prog_data.54 0 PWL FILE "469121.pwl"
Vprog_data.55 prog_data.55 0 PWL FILE "469122.pwl"
Vprog_data.56 prog_data.56 0 PWL FILE "469123.pwl"
Vprog_data.57 prog_data.57 0 PWL FILE "469124.pwl"
Vprog_data.58 prog_data.58 0 PWL FILE "469125.pwl"
Vprog_data.59 prog_data.59 0 PWL FILE "469126.pwl"
Vprog_data.60 prog_data.60 0 PWL FILE "469127.pwl"
Vprog_data.61 prog_data.61 0 PWL FILE "469128.pwl"
Vprog_data.62 prog_data.62 0 PWL FILE "469129.pwl"
Vprog_data.63 prog_data.63 0 PWL FILE "469130.pwl"
Vprog_data.64 prog_data.64 0 PWL FILE "469131.pwl"
Vprog_data.65 prog_data.65 0 PWL FILE "469132.pwl"
Vprog_data.66 prog_data.66 0 PWL FILE "469133.pwl"
Vprog_data.67 prog_data.67 0 PWL FILE "469134.pwl"
Vprog_data.68 prog_data.68 0 PWL FILE "469135.pwl"
Vprog_data.69 prog_data.69 0 PWL FILE "469136.pwl"
* Initial Conditions
.IC V(clk)=1.8 V(cin)=0.0 V(Xfle6:cout)=0.0 V(prog_done)=1.8 V(in.0)=1.8 V(in.1)=0.0 V(in.2)=0.0 V(in.3)=0.0 V(in.4)=0.0 V(in.5)=0.0 V(prog_data.0)=0.0 V(prog_data.1)=1.8 V(prog_data.2)=0.0 V(prog_data.3)=1.8 V(prog_data.4)=0.0 V(prog_data.5)=1.8 V(prog_data.6)=0.0 V(prog_data.7)=1.8 V(prog_data.8)=0.0 V(prog_data.9)=1.8 V(prog_data.10)=0.0 V(prog_data.11)=1.8 V(prog_data.12)=0.0 V(prog_data.13)=1.8 V(prog_data.14)=0.0 V(prog_data.15)=1.8 V(prog_data.16)=0.0 V(prog_data.17)=1.8 V(prog_data.18)=0.0 V(prog_data.19)=1.8 V(prog_data.20)=0.0 V(prog_data.21)=1.8 V(prog_data.22)=0.0 V(prog_data.23)=1.8 V(prog_data.24)=0.0 V(prog_data.25)=1.8 V(prog_data.26)=0.0 V(prog_data.27)=1.8 V(prog_data.28)=0.0 V(prog_data.29)=1.8 V(prog_data.30)=0.0 V(prog_data.31)=1.8 V(prog_data.32)=0.0 V(prog_data.33)=0.0 V(prog_data.34)=0.0 V(prog_data.35)=0.0 V(prog_data.36)=0.0 V(prog_data.37)=0.0 V(prog_data.38)=0.0 V(prog_data.39)=0.0 V(prog_data.40)=1.8 V(prog_data.41)=1.8 V(prog_data.42)=1.8 V(prog_data.43)=1.8 V(prog_data.44)=1.8 V(prog_data.45)=1.8 V(prog_data.46)=1.8 V(prog_data.47)=1.8 V(prog_data.48)=0.0 V(prog_data.49)=0.0 V(prog_data.50)=0.0 V(prog_data.51)=0.0 V(prog_data.52)=0.0 V(prog_data.53)=0.0 V(prog_data.54)=0.0 V(prog_data.55)=0.0 V(prog_data.56)=1.8 V(prog_data.57)=1.8 V(prog_data.58)=1.8 V(prog_data.59)=1.8 V(prog_data.60)=1.8 V(prog_data.61)=1.8 V(prog_data.62)=1.8 V(prog_data.63)=1.8 V(prog_data.64)=0.0 V(prog_data.65)=1.8 V(prog_data.66)=0.0 V(prog_data.67)=0.0 V(prog_data.68)=1.8 V(prog_data.69)=0.0 V(Xfle6:lut5b_data.0)=0.0 V(Xfle6:lut5b_data.1)=0.0 V(Xfle6:lut5b_data.2)=0.0 V(Xfle6:lut5b_data.3)=0.0 V(Xfle6:lut5b_data.4)=0.0 V(Xfle6:lut5b_data.5)=0.0 V(Xfle6:lut5b_data.6)=0.0 V(Xfle6:lut5b_data.7)=0.0 V(Xfle6:lut5b_data.8)=1.8 V(Xfle6:lut5b_data.9)=1.8 V(Xfle6:lut5b_data.10)=1.8 V(Xfle6:lut5b_data.11)=1.8 V(Xfle6:lut5b_data.12)=1.8 V(Xfle6:lut5b_data.13)=1.8 V(Xfle6:lut5b_data.14)=1.8 V(Xfle6:lut5b_data.15)=1.8 V(Xfle6:lut5b_data.16)=0.0 V(Xfle6:lut5b_data.17)=0.0 V(Xfle6:lut5b_data.18)=0.0 V(Xfle6:lut5b_data.19)=0.0 V(Xfle6:lut5b_data.20)=0.0 V(Xfle6:lut5b_data.21)=0.0 V(Xfle6:lut5b_data.22)=0.0 V(Xfle6:lut5b_data.23)=0.0 V(Xfle6:lut5b_data.24)=1.8 V(Xfle6:lut5b_data.25)=1.8 V(Xfle6:lut5b_data.26)=1.8 V(Xfle6:lut5b_data.27)=1.8 V(Xfle6:lut5b_data.28)=1.8 V(Xfle6:lut5b_data.29)=1.8 V(Xfle6:lut5b_data.30)=1.8 V(Xfle6:lut5b_data.31)=1.8 V(Xfle6:lut5a_data.0)=0.0 V(Xfle6:lut5a_data.1)=1.8 V(Xfle6:lut5a_data.2)=0.0 V(Xfle6:lut5a_data.3)=1.8 V(Xfle6:lut5a_data.4)=0.0 V(Xfle6:lut5a_data.5)=1.8 V(Xfle6:lut5a_data.6)=0.0 V(Xfle6:lut5a_data.7)=1.8 V(Xfle6:lut5a_data.8)=0.0 V(Xfle6:lut5a_data.9)=1.8 V(Xfle6:lut5a_data.10)=0.0 V(Xfle6:lut5a_data.11)=1.8 V(Xfle6:lut5a_data.12)=0.0 V(Xfle6:lut5a_data.13)=1.8 V(Xfle6:lut5a_data.14)=0.0 V(Xfle6:lut5a_data.15)=1.8 V(Xfle6:lut5a_data.16)=0.0 V(Xfle6:lut5a_data.17)=1.8 V(Xfle6:lut5a_data.18)=0.0 V(Xfle6:lut5a_data.19)=1.8 V(Xfle6:lut5a_data.20)=0.0 V(Xfle6:lut5a_data.21)=1.8 V(Xfle6:lut5a_data.22)=0.0 V(Xfle6:lut5a_data.23)=1.8 V(Xfle6:lut5a_data.24)=0.0 V(Xfle6:lut5a_data.25)=1.8 V(Xfle6:lut5a_data.26)=0.0 V(Xfle6:lut5a_data.27)=1.8 V(Xfle6:lut5a_data.28)=0.0 V(Xfle6:lut5a_data.29)=1.8 V(Xfle6:lut5a_data.30)=0.0 V(Xfle6:lut5a_data.31)=1.8 V(Xfle6:fle6_mode.0)=1.8 V(Xfle6:fle6_mode.1)=0.0 V(Xfle6:ffb_disable)=0.0 V(Xfle6:ffa_disable)=0.0 V(Xfle6:adder_mode.0)=0.0 V(Xfle6:adder_mode.1)=1.8 V(Xfle6:ADDER_MODE.0)=0.0 V(Xfle6:ADDER_MODE.1)=0.0 V(Xfle6:ADDER_MODE.2)=0.0 V(Xfle6:ADDER_MODE.3)=0.0 V(Xfle6:ADDER_MODE.4)=0.0 V(Xfle6:ADDER_MODE.5)=0.0 V(Xfle6:ADDER_MODE.6)=1.8 V(Xfle6:ADDER_MODE.7)=0.0 V(Xfle6:ADDER_MODE.8)=0.0 V(Xfle6:ADDER_MODE.9)=0.0 V(Xfle6:ADDER_MODE.10)=0.0 V(Xfle6:ADDER_MODE.11)=0.0 V(Xfle6:ADDER_MODE.12)=0.0 V(Xfle6:ADDER_MODE.13)=0.0 V(Xfle6:ADDER_MODE.14)=0.0 V(Xfle6:ADDER_MODE.15)=0.0 V(Xfle6:ADDER_MODE.16)=0.0 V(Xfle6:ADDER_MODE.17)=0.0 V(Xfle6:ADDER_MODE.18)=0.0 V(Xfle6:ADDER_MODE.19)=0.0 V(Xfle6:ADDER_MODE.20)=0.0 V(Xfle6:ADDER_MODE.21)=0.0 V(Xfle6:ADDER_MODE.22)=0.0 V(Xfle6:ADDER_MODE.23)=0.0 V(Xfle6:ADDER_MODE.24)=0.0 V(Xfle6:ADDER_MODE.25)=0.0 V(Xfle6:ADDER_MODE.26)=0.0 V(Xfle6:ADDER_MODE.27)=0.0 V(Xfle6:ADDER_MODE.28)=0.0 V(Xfle6:ADDER_MODE.29)=0.0 V(Xfle6:ADDER_MODE.30)=0.0 V(Xfle6:ADDER_MODE.31)=0.0 V(Xfle6:ADDER_MODE.32)=0.0 V(Xfle6:ADDER_MODE.33)=0.0 V(Xfle6:ADDER_MODE_CHAIN.0)=0.0 V(Xfle6:ADDER_MODE_CHAIN.1)=1.8 V(Xfle6:ADDER_MODE_CONST0.0)=0.0 V(Xfle6:ADDER_MODE_CONST0.1)=0.0 V(Xfle6:ADDER_MODE_CONST1.0)=1.8 V(Xfle6:ADDER_MODE_CONST1.1)=0.0 V(Xfle6:ADDER_MODE_FABRIC.0)=1.8 V(Xfle6:ADDER_MODE_FABRIC.1)=1.8 V(Xfle6:ADDER_MODE_WIDTH.0)=0.0 V(Xfle6:ADDER_MODE_WIDTH.1)=1.8 V(Xfle6:ADDER_MODE_WIDTH.2)=0.0 V(Xfle6:ADDER_MODE_WIDTH.3)=0.0 V(Xfle6:ADDER_MODE_WIDTH.4)=0.0 V(Xfle6:ADDER_MODE_WIDTH.5)=0.0 V(Xfle6:ADDER_MODE_WIDTH.6)=0.0 V(Xfle6:ADDER_MODE_WIDTH.7)=0.0 V(Xfle6:ADDER_MODE_WIDTH.8)=0.0 V(Xfle6:ADDER_MODE_WIDTH.9)=0.0 V(Xfle6:ADDER_MODE_WIDTH.10)=0.0 V(Xfle6:ADDER_MODE_WIDTH.11)=0.0 V(Xfle6:ADDER_MODE_WIDTH.12)=0.0 V(Xfle6:ADDER_MODE_WIDTH.13)=0.0 V(Xfle6:ADDER_MODE_WIDTH.14)=0.0 V(Xfle6:ADDER_MODE_WIDTH.15)=0.0 V(Xfle6:ADDER_MODE_WIDTH.16)=0.0 V(Xfle6:ADDER_MODE_WIDTH.17)=0.0 V(Xfle6:ADDER_MODE_WIDTH.18)=0.0 V(Xfle6:ADDER_MODE_WIDTH.19)=0.0 V(Xfle6:ADDER_MODE_WIDTH.20)=0.0 V(Xfle6:ADDER_MODE_WIDTH.21)=0.0 V(Xfle6:ADDER_MODE_WIDTH.22)=0.0 V(Xfle6:ADDER_MODE_WIDTH.23)=0.0 V(Xfle6:ADDER_MODE_WIDTH.24)=0.0 V(Xfle6:ADDER_MODE_WIDTH.25)=0.0 V(Xfle6:ADDER_MODE_WIDTH.26)=0.0 V(Xfle6:ADDER_MODE_WIDTH.27)=0.0 V(Xfle6:ADDER_MODE_WIDTH.28)=0.0 V(Xfle6:ADDER_MODE_WIDTH.29)=0.0 V(Xfle6:ADDER_MODE_WIDTH.30)=0.0 V(Xfle6:ADDER_MODE_WIDTH.31)=0.0 V(Xfle6:FFA_DISABLE.0)=0.0 V(Xfle6:FFA_DISABLE.1)=1.8 V(Xfle6:FFA_DISABLE.2)=0.0 V(Xfle6:FFA_DISABLE.3)=0.0 V(Xfle6:FFA_DISABLE.4)=0.0 V(Xfle6:FFA_DISABLE.5)=0.0 V(Xfle6:FFA_DISABLE.6)=1.8 V(Xfle6:FFA_DISABLE.7)=0.0 V(Xfle6:FFA_DISABLE.8)=0.0 V(Xfle6:FFA_DISABLE.9)=0.0 V(Xfle6:FFA_DISABLE.10)=0.0 V(Xfle6:FFA_DISABLE.11)=0.0 V(Xfle6:FFA_DISABLE.12)=0.0 V(Xfle6:FFA_DISABLE.13)=0.0 V(Xfle6:FFA_DISABLE.14)=0.0 V(Xfle6:FFA_DISABLE.15)=0.0 V(Xfle6:FFA_DISABLE.16)=0.0 V(Xfle6:FFA_DISABLE.17)=0.0 V(Xfle6:FFA_DISABLE.18)=0.0 V(Xfle6:FFA_DISABLE.19)=0.0 V(Xfle6:FFA_DISABLE.20)=0.0 V(Xfle6:FFA_DISABLE.21)=0.0 V(Xfle6:FFA_DISABLE.22)=0.0 V(Xfle6:FFA_DISABLE.23)=0.0 V(Xfle6:FFA_DISABLE.24)=0.0 V(Xfle6:FFA_DISABLE.25)=0.0 V(Xfle6:FFA_DISABLE.26)=0.0 V(Xfle6:FFA_DISABLE.27)=0.0 V(Xfle6:FFA_DISABLE.28)=0.0 V(Xfle6:FFA_DISABLE.29)=0.0 V(Xfle6:FFA_DISABLE.30)=0.0 V(Xfle6:FFA_DISABLE.31)=0.0 V(Xfle6:FFA_DISABLE.32)=0.0 V(Xfle6:FFA_DISABLE.33)=0.0 V(Xfle6:FFA_DISABLE.34)=0.0 V(Xfle6:FFB_DISABLE.0)=1.8 V(Xfle6:FFB_DISABLE.1)=1.8 V(Xfle6:FFB_DISABLE.2)=0.0 V(Xfle6:FFB_DISABLE.3)=0.0 V(Xfle6:FFB_DISABLE.4)=0.0 V(Xfle6:FFB_DISABLE.5)=0.0 V(Xfle6:FFB_DISABLE.6)=1.8 V(Xfle6:FFB_DISABLE.7)=0.0 V(Xfle6:FFB_DISABLE.8)=0.0 V(Xfle6:FFB_DISABLE.9)=0.0 V(Xfle6:FFB_DISABLE.10)=0.0 V(Xfle6:FFB_DISABLE.11)=0.0 V(Xfle6:FFB_DISABLE.12)=0.0 V(Xfle6:FFB_DISABLE.13)=0.0 V(Xfle6:FFB_DISABLE.14)=0.0 V(Xfle6:FFB_DISABLE.15)=0.0 V(Xfle6:FFB_DISABLE.16)=0.0 V(Xfle6:FFB_DISABLE.17)=0.0 V(Xfle6:FFB_DISABLE.18)=0.0 V(Xfle6:FFB_DISABLE.19)=0.0 V(Xfle6:FFB_DISABLE.20)=0.0 V(Xfle6:FFB_DISABLE.21)=0.0 V(Xfle6:FFB_DISABLE.22)=0.0 V(Xfle6:FFB_DISABLE.23)=0.0 V(Xfle6:FFB_DISABLE.24)=0.0 V(Xfle6:FFB_DISABLE.25)=0.0 V(Xfle6:FFB_DISABLE.26)=0.0 V(Xfle6:FFB_DISABLE.27)=0.0 V(Xfle6:FFB_DISABLE.28)=0.0 V(Xfle6:FFB_DISABLE.29)=0.0 V(Xfle6:FFB_DISABLE.30)=0.0 V(Xfle6:FFB_DISABLE.31)=0.0 V(Xfle6:FFB_DISABLE.32)=0.0 V(Xfle6:FFB_DISABLE.33)=0.0 V(Xfle6:FFB_DISABLE.34)=0.0 V(Xfle6:FFB_DISABLE.35)=0.0 V(Xfle6:FLE6_MODE.0)=0.0 V(Xfle6:FLE6_MODE.1)=0.0 V(Xfle6:FLE6_MODE.2)=1.8 V(Xfle6:FLE6_MODE.3)=0.0 V(Xfle6:FLE6_MODE.4)=0.0 V(Xfle6:FLE6_MODE.5)=0.0 V(Xfle6:FLE6_MODE.6)=1.8 V(Xfle6:FLE6_MODE.7)=0.0 V(Xfle6:FLE6_MODE.8)=0.0 V(Xfle6:FLE6_MODE.9)=0.0 V(Xfle6:FLE6_MODE.10)=0.0 V(Xfle6:FLE6_MODE.11)=0.0 V(Xfle6:FLE6_MODE.12)=0.0 V(Xfle6:FLE6_MODE.13)=0.0 V(Xfle6:FLE6_MODE.14)=0.0 V(Xfle6:FLE6_MODE.15)=0.0 V(Xfle6:FLE6_MODE.16)=0.0 V(Xfle6:FLE6_MODE.17)=0.0 V(Xfle6:FLE6_MODE.18)=0.0 V(Xfle6:FLE6_MODE.19)=0.0 V(Xfle6:FLE6_MODE.20)=0.0 V(Xfle6:FLE6_MODE.21)=0.0 V(Xfle6:FLE6_MODE.22)=0.0 V(Xfle6:FLE6_MODE.23)=0.0 V(Xfle6:FLE6_MODE.24)=0.0 V(Xfle6:FLE6_MODE.25)=0.0 V(Xfle6:FLE6_MODE.26)=0.0 V(Xfle6:FLE6_MODE.27)=0.0 V(Xfle6:FLE6_MODE.28)=0.0 V(Xfle6:FLE6_MODE.29)=0.0 V(Xfle6:FLE6_MODE.30)=0.0 V(Xfle6:FLE6_MODE.31)=0.0 V(Xfle6:FLE6_MODE.32)=0.0 V(Xfle6:FLE6_MODE.33)=0.0 V(Xfle6:FLE6_MODE.34)=0.0 V(Xfle6:FLE6_MODE.35)=0.0 V(Xfle6:FLE6_MODE.36)=0.0 V(Xfle6:FLE6_MODE_ARITH.0)=1.8 V(Xfle6:FLE6_MODE_ARITH.1)=0.0 V(Xfle6:FLE6_MODE_DISABLED.0)=0.0 V(Xfle6:FLE6_MODE_DISABLED.1)=0.0 V(Xfle6:FLE6_MODE_LUT5X2.0)=1.8 V(Xfle6:FLE6_MODE_LUT5X2.1)=1.8 V(Xfle6:FLE6_MODE_LUT6X1.0)=0.0 V(Xfle6:FLE6_MODE_LUT6X1.1)=1.8 V(Xfle6:FLE6_MODE_WIDTH.0)=0.0 V(Xfle6:FLE6_MODE_WIDTH.1)=1.8 V(Xfle6:FLE6_MODE_WIDTH.2)=0.0 V(Xfle6:FLE6_MODE_WIDTH.3)=0.0 V(Xfle6:FLE6_MODE_WIDTH.4)=0.0 V(Xfle6:FLE6_MODE_WIDTH.5)=0.0 V(Xfle6:FLE6_MODE_WIDTH.6)=0.0 V(Xfle6:FLE6_MODE_WIDTH.7)=0.0 V(Xfle6:FLE6_MODE_WIDTH.8)=0.0 V(Xfle6:FLE6_MODE_WIDTH.9)=0.0 V(Xfle6:FLE6_MODE_WIDTH.10)=0.0 V(Xfle6:FLE6_MODE_WIDTH.11)=0.0 V(Xfle6:FLE6_MODE_WIDTH.12)=0.0 V(Xfle6:FLE6_MODE_WIDTH.13)=0.0 V(Xfle6:FLE6_MODE_WIDTH.14)=0.0 V(Xfle6:FLE6_MODE_WIDTH.15)=0.0 V(Xfle6:FLE6_MODE_WIDTH.16)=0.0 V(Xfle6:FLE6_MODE_WIDTH.17)=0.0 V(Xfle6:FLE6_MODE_WIDTH.18)=0.0 V(Xfle6:FLE6_MODE_WIDTH.19)=0.0 V(Xfle6:FLE6_MODE_WIDTH.20)=0.0 V(Xfle6:FLE6_MODE_WIDTH.21)=0.0 V(Xfle6:FLE6_MODE_WIDTH.22)=0.0 V(Xfle6:FLE6_MODE_WIDTH.23)=0.0 V(Xfle6:FLE6_MODE_WIDTH.24)=0.0 V(Xfle6:FLE6_MODE_WIDTH.25)=0.0 V(Xfle6:FLE6_MODE_WIDTH.26)=0.0 V(Xfle6:FLE6_MODE_WIDTH.27)=0.0 V(Xfle6:FLE6_MODE_WIDTH.28)=0.0 V(Xfle6:FLE6_MODE_WIDTH.29)=0.0 V(Xfle6:FLE6_MODE_WIDTH.30)=0.0 V(Xfle6:FLE6_MODE_WIDTH.31)=0.0 V(Xfle6:LUT5A_DATA.0)=0.0 V(Xfle6:LUT5A_DATA.1)=0.0 V(Xfle6:LUT5A_DATA.2)=0.0 V(Xfle6:LUT5A_DATA.3)=0.0 V(Xfle6:LUT5A_DATA.4)=0.0 V(Xfle6:LUT5A_DATA.5)=0.0 V(Xfle6:LUT5A_DATA.6)=0.0 V(Xfle6:LUT5A_DATA.7)=0.0 V(Xfle6:LUT5A_DATA.8)=0.0 V(Xfle6:LUT5A_DATA.9)=0.0 V(Xfle6:LUT5A_DATA.10)=0.0 V(Xfle6:LUT5A_DATA.11)=0.0 V(Xfle6:LUT5A_DATA.12)=0.0 V(Xfle6:LUT5A_DATA.13)=0.0 V(Xfle6:LUT5A_DATA.14)=0.0 V(Xfle6:LUT5A_DATA.15)=0.0 V(Xfle6:LUT5A_DATA.16)=0.0 V(Xfle6:LUT5A_DATA.17)=0.0 V(Xfle6:LUT5A_DATA.18)=0.0 V(Xfle6:LUT5A_DATA.19)=0.0 V(Xfle6:LUT5A_DATA.20)=0.0 V(Xfle6:LUT5A_DATA.21)=0.0 V(Xfle6:LUT5A_DATA.22)=0.0 V(Xfle6:LUT5A_DATA.23)=0.0 V(Xfle6:LUT5A_DATA.24)=0.0 V(Xfle6:LUT5A_DATA.25)=0.0 V(Xfle6:LUT5A_DATA.26)=0.0 V(Xfle6:LUT5A_DATA.27)=0.0 V(Xfle6:LUT5A_DATA.28)=0.0 V(Xfle6:LUT5A_DATA.29)=0.0 V(Xfle6:LUT5A_DATA.30)=0.0 V(Xfle6:LUT5A_DATA.31)=0.0 V(Xfle6:LUT5B_DATA.0)=0.0 V(Xfle6:LUT5B_DATA.1)=0.0 V(Xfle6:LUT5B_DATA.2)=0.0 V(Xfle6:LUT5B_DATA.3)=0.0 V(Xfle6:LUT5B_DATA.4)=0.0 V(Xfle6:LUT5B_DATA.5)=1.8 V(Xfle6:LUT5B_DATA.6)=0.0 V(Xfle6:LUT5B_DATA.7)=0.0 V(Xfle6:LUT5B_DATA.8)=0.0 V(Xfle6:LUT5B_DATA.9)=0.0 V(Xfle6:LUT5B_DATA.10)=0.0 V(Xfle6:LUT5B_DATA.11)=0.0 V(Xfle6:LUT5B_DATA.12)=0.0 V(Xfle6:LUT5B_DATA.13)=0.0 V(Xfle6:LUT5B_DATA.14)=0.0 V(Xfle6:LUT5B_DATA.15)=0.0 V(Xfle6:LUT5B_DATA.16)=0.0 V(Xfle6:LUT5B_DATA.17)=0.0 V(Xfle6:LUT5B_DATA.18)=0.0 V(Xfle6:LUT5B_DATA.19)=0.0 V(Xfle6:LUT5B_DATA.20)=0.0 V(Xfle6:LUT5B_DATA.21)=0.0 V(Xfle6:LUT5B_DATA.22)=0.0 V(Xfle6:LUT5B_DATA.23)=0.0 V(Xfle6:LUT5B_DATA.24)=0.0 V(Xfle6:LUT5B_DATA.25)=0.0 V(Xfle6:LUT5B_DATA.26)=0.0 V(Xfle6:LUT5B_DATA.27)=0.0 V(Xfle6:LUT5B_DATA.28)=0.0 V(Xfle6:LUT5B_DATA.29)=0.0 V(Xfle6:LUT5B_DATA.30)=0.0 V(Xfle6:LUT5B_DATA.31)=0.0 V(Xfle6:LUT5B_DATA.32)=0.0 V(Xfle6:LUT5_DATA_WIDTH.0)=0.0 V(Xfle6:LUT5_DATA_WIDTH.1)=0.0 V(Xfle6:LUT5_DATA_WIDTH.2)=0.0 V(Xfle6:LUT5_DATA_WIDTH.3)=0.0 V(Xfle6:LUT5_DATA_WIDTH.4)=0.0 V(Xfle6:LUT5_DATA_WIDTH.5)=1.8 V(Xfle6:LUT5_DATA_WIDTH.6)=0.0 V(Xfle6:LUT5_DATA_WIDTH.7)=0.0 V(Xfle6:LUT5_DATA_WIDTH.8)=0.0 V(Xfle6:LUT5_DATA_WIDTH.9)=0.0 V(Xfle6:LUT5_DATA_WIDTH.10)=0.0 V(Xfle6:LUT5_DATA_WIDTH.11)=0.0 V(Xfle6:LUT5_DATA_WIDTH.12)=0.0 V(Xfle6:LUT5_DATA_WIDTH.13)=0.0 V(Xfle6:LUT5_DATA_WIDTH.14)=0.0 V(Xfle6:LUT5_DATA_WIDTH.15)=0.0 V(Xfle6:LUT5_DATA_WIDTH.16)=0.0 V(Xfle6:LUT5_DATA_WIDTH.17)=0.0 V(Xfle6:LUT5_DATA_WIDTH.18)=0.0 V(Xfle6:LUT5_DATA_WIDTH.19)=0.0 V(Xfle6:LUT5_DATA_WIDTH.20)=0.0 V(Xfle6:LUT5_DATA_WIDTH.21)=0.0 V(Xfle6:LUT5_DATA_WIDTH.22)=0.0 V(Xfle6:LUT5_DATA_WIDTH.23)=0.0 V(Xfle6:LUT5_DATA_WIDTH.24)=0.0 V(Xfle6:LUT5_DATA_WIDTH.25)=0.0 V(Xfle6:LUT5_DATA_WIDTH.26)=0.0 V(Xfle6:LUT5_DATA_WIDTH.27)=0.0 V(Xfle6:LUT5_DATA_WIDTH.28)=0.0 V(Xfle6:LUT5_DATA_WIDTH.29)=0.0 V(Xfle6:LUT5_DATA_WIDTH.30)=0.0 V(Xfle6:LUT5_DATA_WIDTH.31)=0.0 V(Xfle6:internal_cin)=0.0 V(Xfle6:internal_ff.0)=1.8 V(Xfle6:internal_ff.1)=0.0 V(Xfle6:internal_lut.0)=1.8 V(Xfle6:internal_lut.1)=0.0 V(Xfle6:internal_sum.0)=1.8 V(Xfle6:internal_sum.1)=0.0 V(Xfle6:out.0)=1.8 V(Xfle6:out.1)=0.0
.global VDD
VSS VSS 0 0
VDD VDD 0 1.8
.print tran v(Xfle6:VSS) v(Xfle6:clk) v(Xfle6:in.0) v(Xfle6:in.1) v(Xfle6:in.2) v(Xfle6:in.3) v(Xfle6:in.4) v(Xfle6:in.5) v(Xfle6:cin) v(Xfle6:out.0) v(Xfle6:out.1) v(Xfle6:cout) v(Xfle6:prog_done) v(Xfle6:prog_data.0) v(Xfle6:prog_data.1) v(Xfle6:prog_data.2) v(Xfle6:prog_data.3) v(Xfle6:prog_data.4) v(Xfle6:prog_data.5) v(Xfle6:prog_data.6) v(Xfle6:prog_data.7) v(Xfle6:prog_data.8) v(Xfle6:prog_data.9) v(Xfle6:prog_data.10) v(Xfle6:prog_data.11) v(Xfle6:prog_data.12) v(Xfle6:prog_data.13) v(Xfle6:prog_data.14) v(Xfle6:prog_data.15) v(Xfle6:prog_data.16) v(Xfle6:prog_data.17) v(Xfle6:prog_data.18) v(Xfle6:prog_data.19) v(Xfle6:prog_data.20) v(Xfle6:prog_data.21) v(Xfle6:prog_data.22) v(Xfle6:prog_data.23) v(Xfle6:prog_data.24) v(Xfle6:prog_data.25) v(Xfle6:prog_data.26) v(Xfle6:prog_data.27) v(Xfle6:prog_data.28) v(Xfle6:prog_data.29) v(Xfle6:prog_data.30) v(Xfle6:prog_data.31) v(Xfle6:prog_data.32) v(Xfle6:prog_data.33) v(Xfle6:prog_data.34) v(Xfle6:prog_data.35) v(Xfle6:prog_data.36) v(Xfle6:prog_data.37) v(Xfle6:prog_data.38) v(Xfle6:prog_data.39) v(Xfle6:prog_data.40) v(Xfle6:prog_data.41) v(Xfle6:prog_data.42) v(Xfle6:prog_data.43) v(Xfle6:prog_data.44) v(Xfle6:prog_data.45) v(Xfle6:prog_data.46) v(Xfle6:prog_data.47) v(Xfle6:prog_data.48) v(Xfle6:prog_data.49) v(Xfle6:prog_data.50) v(Xfle6:prog_data.51) v(Xfle6:prog_data.52) v(Xfle6:prog_data.53) v(Xfle6:prog_data.54) v(Xfle6:prog_data.55) v(Xfle6:prog_data.56) v(Xfle6:prog_data.57) v(Xfle6:prog_data.58) v(Xfle6:prog_data.59) v(Xfle6:prog_data.60) v(Xfle6:prog_data.61) v(Xfle6:prog_data.62) v(Xfle6:prog_data.63) v(Xfle6:prog_data.64) v(Xfle6:prog_data.65) v(Xfle6:prog_data.66) v(Xfle6:prog_data.67) v(Xfle6:prog_data.68) v(Xfle6:prog_data.69)
.end
